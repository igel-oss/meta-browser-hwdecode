SRC_URI = " \
    git://github.com/igel-oss/gst-plugin-vspfilter.git;protocol=https;nobranch=1 \
    file://${VSPFILTER_CONF} \
"

SRCREV = "27093645d68292d203e69bfe34475db8bfd9b6e3"
