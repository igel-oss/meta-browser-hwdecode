SRC_URI += " \
           file://0001-appsrc-Clear-EOS-on-flush.patch \
          "

FILESEXTRAPATHS_append := "${THISDIR}/${PN}_${PV}:"
